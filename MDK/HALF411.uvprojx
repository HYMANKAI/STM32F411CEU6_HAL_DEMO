# Keil uVision project HALF411.uvprojx, settings and files
target STM32F411XE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HALF411 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ..\CORE;..\HALLIIB\Inc;..\STARTUP;..\SYSTEM\inc;..\USER;..\HARDWARE\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group STARTUP
    ../STARTUP/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_conf.h
  group HALLIB
    ../HALLIIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group SYSTEM
    ../SYSTEM/src/: delay.c sys.c usart.c
  group HARDWARE
    ../HARDWARE/src/: BOARD.c IIC.c OLED.c SPI.c MPU6050.c ICM20602.c TIMER.c
  group USER
    ../USER/: main.c
